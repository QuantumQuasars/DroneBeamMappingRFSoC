options:
  parameters:
    author: Jason Gallicchio
    copyright: 2025 BSD License
    generate_options: qt_gui
    id: Zadoff_Chu_Demonstrator
    output_language: python
    title: Zadoff Chu Cross Correlation Demonstrator
  states: {}

blocks:
- name: IIR_alpha
  id: variable_qtgui_range
  parameters:
    comment: |-
      alpha averaging parameter
      alpha=1 is no averaging
      alpha=0 is averaging forever back
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.01'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: full range center_freq
    start: 50e6
    step: 5e6
    stop: 6000e6
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      50 MHz leads to
       lots of underflows
    value: int(25e6)
  states: {}
- name: samples_offset
  id: variable_qtgui_range
  parameters:
    start: '-vector_size/2'
    step: '0.01'
    stop: +vector_size/2
    value: '0'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: |-
      ZC sequence chirp
      repeats after this
      many samples.
      FFTs and correlations
      are processed
      in chunks of this size
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize the spectrum
    const: '[1/vector_size]*vector_size'
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      linear phase shift:
      compensate by hand  for
      mis-aligned samples
    const: np.exp(-2j*np.pi*samples_offset*np.arange(vector_size)/vector_size)
    type: complex
    vlen: vector_size
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: radians to degrees
    const: 180/np.pi
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      a cheap way of 
      doing fftshift
      to center the 0 
      frequency bin
      Useful for spectrum magnitude
      Annoying discontinuity in 
      the middle for phase
    num_items: vector_size//2
    type: complex
  states: {state: bypassed}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: zc_sequence_code.zc_sequence(N=vector_size, u=1, q=0)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vector_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    comment: |-
      IFFT: take the correlation spectrum
      and turn it into a correlation in time
    fft_size: vector_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(vector_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: cross spectrum
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: raw rx spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      IFFT and here FFT again
      rectangular window for cyclic signal
    fc: '0'
    fftsize: vector_size
    label1: FFT of IFFT
    type: complex
    wintype: window.WIN_RECTANGULAR
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      show ZC sequence
      (chirp)
      real and imaginary
    label1: ZC Sequence (real)
    label2: ZC Sequence (imag)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: raw rx (real)
    label2: raw rx (imag)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Correlation Re
    label2: Correlation Im
    size: vector_size
    srate: samp_rate
    type: complex
    ymax: vector_size*1.2
    ymin: '-vector_size*0.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    comment: Correlation (in time)
    label1: Correlation Mag
    marker1: '0'
    size: vector_size
    srate: samp_rate
    type: float
    ymax: '20'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Cross Spectrum Mag
    size: vector_size
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Cross Spectrum Phase
    size: vector_size
    srate: samp_rate
    type: float
    ymax: '180'
    ymin: '-180'
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: IIR_alpha
    comment: |-
      average repeatnig sample windows,
      with exponentially decreasing 
      weights into the past
    type: complex
    vlen: vector_size
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_args: '"type=b200"'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_args: '"type=b200"'
    gain0: rx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zc_sequence_code
  id: epy_module
  parameters:
    source_code: "import numpy as np\nfrom pylab import gcd\n\ndef zc_sequence(N=2**10-1, u=17, q=0):\n    '''\n    returns a complex numpy array corresponding to a Zadoff-Chu sequence\n    according to https://en.wikipedia.org/wiki/Zadoff%E2%80%93Chu_sequence\n    This is the \"ideal ZC sequence\" or \"Wikipedia ZC sequence\" or \"textbook ZC sequence\"\n\n    u is the interesting prime parameter. u=1 is a chirp. It should be relatively prime to NZC\n    q is a kind of shift. \n    q=0 is just a Chu sequence. Non-zero q is just cyclically-shifted and constant-phased\n    '''\n    \n    cf = N%2 # Boring parameter: 0 for even, 1 for odd\n    assert(gcd(u,N)==1)  # Check u and N are relatively prime (share no common factors other than 1, otherwise subsequences will repeat)\n                         # If this fails, the spectrum won't be flat! It'll have periodic structure\n    i = np.arange(N)  # index of sequence element.\n    zu = np.exp(-1j*np.pi*u*i*(i+cf+2*q)/N)\n    \n    # Optional Check that it's periodic even if N is even (even though Wikipedia clames otherwise)\n    zu_next_element_off_the_end = np.exp(-1j*np.pi*u*N*(N+cf+2*q)/N)\n    assert( np.isclose(zu[0], zu_next_element_off_the_end) )\n    \n    return zu\n\n"
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_2_0_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fft_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0_2_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_skiphead_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_stream_to_vector_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_skiphead_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_vector_to_stream_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', fft_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
